<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\comp_dac.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>