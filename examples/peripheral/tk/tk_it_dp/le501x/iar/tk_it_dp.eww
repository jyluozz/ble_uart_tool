<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\tk_it_dp.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>