<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\single_dac_channel_voltage.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>